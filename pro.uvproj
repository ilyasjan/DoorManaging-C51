# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C51RC STC90C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000) MODP2
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
